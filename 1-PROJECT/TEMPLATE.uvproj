# Keil uVision project TEMPLATE.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEMPLATE +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\2-CORE;..\3-STM32F10x_FWLib\inc;..\4-HARDWARE\LED;..\4-HARDWARE\KEY;..\4-HARDWARE\LCD;..\4-HARDWARE\TOUCH;..\4-HARDWARE\24CXX;..\4-HARDWARE\IIC;..\4-HARDWARE\W25QXX;..\4-HARDWARE\SPI;..\5-TOOL\delay;..\5-TOOL\sys;..\5-TOOL\usart;..\7-USER;..\5-TOOL\touch;..\4-HARDWARE\TIMER;..\4-HARDWARE\PWM;..\4-HARDWARE\TOUCHKEY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../2-CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FIRMWARE
    ../3-STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c
  group HARDWARE
    ../4-HARDWARE/LED/: LED.c
    ../4-HARDWARE/KEY/: key.c
    ../4-HARDWARE/LCD/: lcd.c
    ../4-HARDWARE/TOUCH/: touch.c ctiic.c ft5206.c gt9147.c ott2001a.c
    ../4-HARDWARE/24CXX/: 24cxx.c
    ../4-HARDWARE/IIC/: myiic.c
    ../4-HARDWARE/W25QXX/: w25qxx.c
    ../4-HARDWARE/SPI/: spi.c
    ../4-HARDWARE/TIMER/: TIMER.c
    ../4-HARDWARE/TOUCHKEY/: touch_key.c
  group TOOL
    ../5-TOOL/delay/: delay.c
    ../5-TOOL/sys/: sys.c
    ../5-TOOL/usart/: usart.c
    ../5-TOOL/touch/: touch_func.c
  group CURSTOM
    ../7-USER/: main.c stm32f10x_it.c
